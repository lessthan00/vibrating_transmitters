# Repository lessthan00/vibrating_transmitters

File README.md:

# vibrating_transmitters  

依赖的项目:  
https://github.com/lessthan00/ADXL345BCCZ-RL7_a  
https://github.com/lessthan00/current-to-voltage-loop  
https://github.com/lessthan00/HT7333  
https://github.com/lessthan00/nucleo-stm32-pin32-kicad-b  
https://github.com/lessthan00/TLV70450DBVR  
  
## 主意事项  
  
控制电流损耗  
  
SMF3.3CA 反向漏电流Ir 500uA  
SMAJ5.0CA Ir 800uA  
SMAJ36CA Ir 1uA  
  
慎重选择  
  
LED 都去掉,驱动LED 要消耗大约1mA  
  
## MCU选择  
  
STM32L432KCBU6  
PIN31->GND  
PIN16->GND  
PIN33->GND  
  
## 通讯引脚选择  
  
PA3->GPIO_down  
PA4->DAC1_OUT1  
PA5->SPI1_SCK  
PA6->SPI1_MISO  
PA7->SPI1_MOSI  
PA8->INT2  
PA9->INT1  
  
## 底板绘制  
  
引入接口  
PCB引入模块的SVG图片,以对准位置  
  
## 最后Gerber文件生成  
  
所有模块加底板画成一个大板子->转嘉立创打板.

## KiCad design PCB/vibrating_transmitters_pcb.kicad_pcb

Parts:
J1, J12: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J3: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
J7: Conn_01x15; PinHeader_1x15_P2.54mm_Vertical
J9: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical

Connections:
+3.3V: J7.3, J7.4, J9.3, J12.1
+5V: J1.3, J3.2, J9.1, J12.3
+24V: J1.1, J3.3
/CS: J7.9, J9.9
/DAC_OUT: J3.4, J7.13
/INT1: J7.7, J9.10
/INT2: J7.8, J9.8
/PA2: J7.15
/PA3: J7.14
/PA5: J7.12, J9.2
/PA6: J7.11, J9.6
/PA7: J7.10, J9.4
/PA9: J7.6
/PA10: J7.5
/VS: J9.7
/loop+: J3.6
/loop-: J3.5
GND: J1.2, J3.1, J7.1, J7.2, J9.5, J12.2

Notes on the sheet:
IIC_ADDR
SPI-SPC
SPI-MISO
SCL
这样应该比较好画底部的板子, 不用考虑引脚间距
IIC_SCL
SPI-MOSI
IIC_SDA
SDO
SDA

Board: 2 copper layers, 24.0 x 70.0 mm, 5 parts (1 on the bottom side), 11 nets.

## KiCad design product/HT7333.kicad_pcb

Board: 2 copper layers, 14.0 x 18.0 mm, 8 parts (2 on the bottom side), 3 nets.

Parts:
C1, C3: 10uF; C_1206_3216Metric
C2, C4: 100nF; C_1206_3216Metric
D1: SMAJ12CA; D_SMA_TVS
D2: SMF3.3CA; D_SOD-123F
J1: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
U1: HT7333; SOT-89-3

Connections:
+3.3V: C3.1, C4.1, D2.2 (A), J1.1, U1.3 (OUT)
+12V: C1.1, C2.1, D1.2 (A), J1.3, U1.2 (IN)
GND: C1.2, C2.2, C3.2, C4.2, D1.1 (K), D2.1 (K), J1.2, U1.1

## KiCad design product/TLV70450DBVR.kicad_pcb

Board: 2 copper layers, 21.0 x 11.0 mm, 8 parts (3 on the bottom side), 3 nets.

Parts:
C1, C3: 10uF; C_1206_3216Metric
C2, C4: 100nF; C_1206_3216Metric
D1: SMAJ24CA; D_SMA_TVS
D2: SMAJ5.0CA; D_SMA_TVS
J1: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
U1: TLV70450DBVR; SOT-23-5

Connections:
+5V: C3.1, C4.1, D2.2 (A), J1.3, U1.3 (OUT)
+24V: C1.1, C2.1, D1.2 (A), J1.1, U1.2 (IN)
GND: C1.2, C2.2, C3.2, C4.2, D1.1 (K), D2.1 (K), J1.2, U1.1 (GND)

## KiCad design product/ADXL345BCCZ.kicad_pcb

Board: 2 copper layers, 24.0 x 20.0 mm, 18 parts (9 on the bottom side), 11 nets.

Parts:
C1, C5: 10uF; C_1206_3216Metric
C2, C3, C4, C6: 100nF; C_1206_3216Metric
D1: SMAJ5.0CA; D_SMA_TVS
D2: SMF3.3CA; D_SOD-123F
J3, J5: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J9: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
LED1: red; LED_1206_3216Metric
R1, R2, R3, R4: 10K; R_1206_3216Metric
U1: ADXL345; LGA-14_3x5mm_P0.8mm_LayoutBorder1x6y
U2: LDI1117-3.3U; SOT-89-3

Connections:
+3.3V: C4.1, C5.1, C6.1, D2.2 (A), J5.2, J9.3, R1.1, R2.1, R3.1, R4.1, U1.1 (Vdd_I/O), U2.2 (OUT)
+5V: C1.1, C3.1, D1.2 (A), J9.1, U2.3 (IN)
/CS: J9.9, R1.2, U1.7 (~CS)
/INT1: J9.10, U1.8 (INT1)
/INT2: J9.8, U1.9 (INT2)
/SCL: J9.2, R2.2, U1.14 (SCL/SCLK)
/SDA: J9.4, R3.2, U1.13 (SDA/SDI/SDIO)
/SDO: J3.2, J9.6, U1.12 (SDO/ADDR)
/VS: C2.1, J5.1, J9.7, U1.6 (Vs)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D1.1 (K), D2.1 (K), J3.1, J9.5, LED1.1 (K), U1.2 (GND), U1.4 (GND), U1.5 (GND), U2.1
unnamed: LED1.2 (A), R4.2

## KiCad design product/nucleo-stm32-pin32-kicad-b.kicad_pcb

Board: 2 copper layers, 32.0 x 47.0 mm, 33 parts (14 on the bottom side), 39 nets.

Parts:
C1, C2: 10uF; C_1206_3216Metric
C3, C4, C5, C7, C9: 100nF; C_1206_3216Metric
C6, C8: 22pF; C_0603_1608Metric
D1: SMAJ5.0CA; D_SMA_TVS
D2: SMF3.3CA; D_SOD-123F
FB1: 600Ω100Mhz; Ferrite_1206_3216Metric
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HCTL_HC-TYPE-C-16P-01A
J2, J3, J4, J6, J8: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J5, J7: Conn_01x15; PinHeader_1x15_P2.54mm_Vertical
J16: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
LED2: 5Vred; LED_1206_3216Metric
LED3: 3V3red; LED_1206_3216Metric
LED4: green; LED_1206_3216Metric
R1, R2, R3: 5.1K; R_1206_3216Metric
R4, R5: 10K; R_1206_3216Metric
SW1: SW_Push; SW_PUSH_6mm_H7.3mm
U1: STM32L432K_B-C_Ux; LQFP-32_7x7mm_P0.8mm_QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm
U2: AMS1117-3.3; SOT-223-3_TabPin2
X1: Crystal_Generic_GND24; Crystal_SMD_SeikoEpson_TSX3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C3.1, C5.1, C9.1, D2.2 (A), J6.1, J8.2, J16.1, LED3.2 (A), R4.1, U1.1 (VDD), U1.17 (VDD)
/BOOT0: J2.1, R1.2
/JTDI: J5.7, J16.6, U1.25 (PA15)
/JTDO: J5.8, J16.7, U1.26 (PB3)
/NRST: C4.1, J5.13, J16.5, R4.2, SW1.2, U1.4 (NRST)
/OSC32+: C8.1, U1.2 (PC14), X1.3
/OSC32-: C6.1, U1.3 (PC15), X1.1
/PA0: J5.14, U1.6 (PA0)
/PA1: J5.15, U1.7 (PA1)
/PA2: J7.15, U1.8 (PA2)
/PA3: J7.14, U1.9 (PA3)
/PA4: J7.13, U1.10 (PA4)
/PA5: J7.12, U1.11 (PA5)
/PA6: J7.11, U1.12 (PA6)
/PA7: J7.10, U1.13 (PA7)
/PA8: J7.7, U1.18 (PA8)
/PA9: J7.6, U1.19 (PA9)
/PA10: J7.5, U1.20 (PA10)
/PB0: J7.9, U1.14 (PB0)
/PB1: J7.8, U1.15 (PB1)
/PB4: J5.9, R5.1, U1.27 (PB4)
/PB5: J5.10, U1.28 (PB5)
/PB6: J5.11, U1.29 (PB6)
/PB7: J5.12, U1.30 (PB7)
/PIN3_3V: C2.1, J6.2, J7.3, J7.4, U2.2 (VO)
/SWCLK: J5.6, J16.3, U1.24 (PA14)
/SWDIO: J5.5, J16.2, U1.23 (PA13)
/USB+: J1.A6 (D+), J1.B6 (D+), U1.22 (PA12)
/USB-: J1.A7 (D-), J1.B7 (D-), U1.21 (PA11)
/VSS2: J3.2, U1.16 (VSS)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, D1.1 (K), D2.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J3.1, J4.2, J5.1, J5.2, J7.1, J7.2, J16.4, LED2.1 (K), LED3.1 (K), LED4.1 (K), R1.1, R2.2, R3.2, SW1.1, U1.33 (VSS), U2.1 (GND), X1.2, X1.4
unnamed: J1.A5 (CC1), R3.1
unnamed: J1.B5 (CC2), R2.1
unnamed: J2.2, U1.31 (PH3)
unnamed: J4.1, U1.32 (VSS)
unnamed: FB1.1, J8.1
unnamed: LED4.2 (A), R5.2
VBUS: C1.1, D1.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J5.3, J5.4, LED2.2 (A), U2.3 (VI)
VDDA: C7.1, FB1.2, U1.5 (VDDA)
